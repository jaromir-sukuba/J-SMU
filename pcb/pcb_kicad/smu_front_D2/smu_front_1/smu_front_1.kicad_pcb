# Repository jaromir-sukuba/J-SMU (continued)

## KiCad design pcb/pcb_kicad/smu_main_A1/smu_main_1.kicad_pcb

Parts:
C1, C4: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3, C5, C6, C9, C10, C11, C12, C13, C14: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C8, C15: 22u; CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder
C16, C17: 270p; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: BAV70; SOT-23
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO7380_Pad
J1: Conn_01x03_Male; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
J2: Conn_01x03_Male; Molex_KK-396_A-41791-0003_1x03_P3.96mm_Vertical
J3: Conn_01x05_Male; Molex_KK-254_AE-6410-05A_1x05_P2.54mm_Vertical
J4: Conn_01x06_Male; Molex_KK-396_A-41791-0006_1x06_P3.96mm_Vertical
J5: Conn_01x05_Male; Molex_KK-396_A-41791-0005_1x05_P3.96mm_Vertical
K1, K2: EC2-5NU; Relay_DPDT_Kemet_EC2
Q1, Q2: BC847; SOT-23
R1, R2, R3, R6: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9: TestPoint; TestPoint_Loop_D1.80mm_Drill1.0mm_Beaded
U1: uA7805; TO-263-3_TabPin2

Connections:
15VO+: J2.1; also elsewhere on the board
15VO-: J2.3; also elsewhere on the board
+5V: C11.1, C12.1, C13.1, C14.1, C15.1, U1.3 (OUT); also elsewhere on the board
+15V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C9.1, C10.1, D1.3 (K), J1.1, J4.3, K1.1, K2.1, U1.1 (IN); also elsewhere on the board
-15V: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, J1.3, J4.6; also elsewhere on the board
/AMP: J4.4, TP3.1; also elsewhere on the board
/IM: TP1.1; also elsewhere on the board
/IOUT: C16.1, K1.9, K2.3, TP6.1; also elsewhere on the board
/RE_ON: K1.12, R5.1
/RE_REM: K2.12, R4.2
/VM: TP2.1; also elsewhere on the board
/VREF+: TP9.1; also elsewhere on the board
/smu_ctrl/I_CLAMP: J3.5; also elsewhere on the board
/smu_ctrl/I_GND: J3.1; also elsewhere on the board
/smu_ctrl/I_RX: J3.3; also elsewhere on the board
/smu_ctrl/I_TX: J3.4; also elsewhere on the board
/smu_ctrl/I_VCC: J3.2; also elsewhere on the board
/smu_ctrl/OUT_ON: R6.1; also elsewhere on the board
/smu_ctrl/PA_CTRL_A: R3.2; also elsewhere on the board
/smu_ctrl/PA_CTRL_B: R2.2; also elsewhere on the board
/smu_ctrl/REMOTE: R1.2; also elsewhere on the board
/smu_ivmeas/GRD_OUT: K1.4; also elsewhere on the board
/smu_ivmeas/SEN+: K2.4; also elsewhere on the board
/smu_ivmeas/SEN-: K2.9; also elsewhere on the board
GND: C7.2, C8.1, C11.2, C12.2, C13.2, C14.2, C15.2, J1.2, J4.5, Q1.2 (E), Q2.2 (E), TP4.1, TP7.1, TP8.1, U1.2 (GND); also elsewhere on the board
HVG: C17.2, J2.2, J5.1, K2.10, TP5.1; also elsewhere on the board
unnamed: C16.2, C17.1
unnamed: D1.1 (A), Q1.3 (C), R4.1
unnamed: D1.2 (A), Q2.3 (C), R5.2
unnamed: J4.1, R2.1
unnamed: J4.2, R3.1
unnamed: Q1.1 (B), R1.1
unnamed: Q2.1 (B), R6.2
T_GUARD: J5.5, K1.5
T_OUT: J5.4, K1.8
T_SENH: J5.3, K2.5
T_SENL: J5.2, K2.8

Notes on the sheet:
Control block, Error amplifier I/V measurement amplifiers and range switching Output relay block
Analog power supply connector, decoupling, local 5V regulator
Decoupling capacitors
Floating amp power connector
Test points
Mounting holes
Output connector
JSMU - main analog board A1

Parts:
C18, C19, C20: 15p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C21: 10n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C22: 150p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2, D3: BAV99; SOT-23
R7, R8, R9, R10, R11, R12: 10k00; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13, R14, R16: 20k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R17, R19, R21: 10k1; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18: 30k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R20: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R22: 200k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R23: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U2: DG411xY; SOIC-16_3.9x9.9mm_P1.27mm
U3: OPA202; SOIC-8_3.9x4.9mm_P1.27mm
U4, U5, U6, U8, U9: OPA140; SOIC-8_3.9x4.9mm_P1.27mm
U7: LM393; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: R17.1, U2.12 (VL); also elsewhere on the board
+15V: U2.13 (V+), U3.7 (V+), U4.7 (V+), U5.7 (V+), U6.7 (V+), U7.8 (V+), U8.7 (V+), U9.7 (V+); also elsewhere on the board
-15V: U2.4 (V-), U3.4 (V-), U4.4 (V-), U5.4 (V-), U6.4 (V-), U7.4 (V-), U8.4 (V-), U9.4 (V-); also elsewhere on the board
/AMP: U9.2 (-), U9.6; also elsewhere on the board
/IM: U2.6, U2.15; also elsewhere on the board
/VM: U2.2, U2.10; also elsewhere on the board
/smu_ctrl/CL+: R7.2; also elsewhere on the board
/smu_ctrl/CL-: R9.2; also elsewhere on the board
/smu_ctrl/CLAMP: R17.2, R18.1; also elsewhere on the board
/smu_ctrl/FDACN: R11.2; also elsewhere on the board
/smu_ctrl/IMODE: U2.8, U2.9; also elsewhere on the board
/smu_ctrl/VMODE: U2.1, U2.16; also elsewhere on the board
GND: U2.5 (GND), U7.2 (-), U7.5 (+), U8.3 (+); also elsewhere on the board
HVG: R22.1, R23.1; also elsewhere on the board
unnamed: C18.1, D2.3 (K), U4.6, U7.3 (+)
unnamed: C18.2, D2.2 (A), R13.1, U4.2 (-)
unnamed: C19.1, D3.3 (K), U5.6, U7.6 (_)
unnamed: C19.2, D3.1 (K), R14.1, U5.2 (-)
unnamed: C20.1, R15.2, U6.6
unnamed: C20.2, R16.1, U6.2 (-)
unnamed: C21.1, R21.2, U8.6
unnamed: C21.2, R20.1
unnamed: C22.1, R23.2
unnamed: C22.2, R21.1, R22.2, U9.3 (+)
unnamed: D2.1 (K), D3.2 (A), R13.2, R14.2, R15.1, R16.2, R19.2
unnamed: R7.1, R8.1, U4.3 (+)
unnamed: R9.1, R10.1, U5.3 (+)
unnamed: R8.2, R10.2, U2.11, U2.14
unnamed: R11.1, R12.1, U6.3 (+)
unnamed: R12.2, U3.2 (-), U3.6
unnamed: R18.2, U7.1, U7.7
unnamed: R19.1, R20.2, U8.2 (-)
unnamed: U2.3, U2.7, U3.3 (+)

Parts:
C23: 22p; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C24, C26, C27: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C25: 150p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C28: 270p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C29, C30, C31: 680p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C32: 22p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D4, D5, D6, D7: BAV199; SOT-23
R24: 4k7; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R25: 10k1; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R26: 4k7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R27, R51, R55: 10k1; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R28, R31, R33, R34, R35: 10k00; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R29: 300k00; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R30: 22k10; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R32, R36, R37: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R38: 2M00; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R39: 200k00; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R40: 20k5; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R41: 2k00; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R42: 200R00; R_MiniMELF_MMA-0204
R43, R44, R45, R46: 78R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R47, R48, R49, R50: 4R70; R_2512_6332Metric
R52, R54: 100k00; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R53, R57: 250k00; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R56, R58: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R59: 1k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
U10, U11, U13, U14, U19, U20: OPA140; SOIC-8_3.9x4.9mm_P1.27mm
U12: TLP170D; SO-4_4.4x3.9mm_P2.54mm
U15, U16: DG444; SOIC-16_3.9x9.9mm_P1.27mm
U17: AQY221R; SO-4_4.4x3.9mm_P2.54mm
U18: DNP; SO-4_4.4x3.9mm_P2.54mm
U21: TL071; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
15VO+: C24.2, D5.2 (A), D6.2 (A), U11.7 (V+); also elsewhere on the board
15VO-: C24.1, D5.1 (K), D6.1 (K), U11.4 (V-); also elsewhere on the board
+5V: R32.1, R36.1, R37.1, U15.12 (VL), U16.12 (VL); also elsewhere on the board
+15V: C26.2, C27.2, D4.2 (A), U10.7 (V+), U13.7 (V+), U14.7 (V+), U15.13 (V+), U16.13 (V+), U19.7 (V+), U20.7 (V+), U21.7 (V+); also elsewhere on the board
-15V: C26.1, C27.1, D4.1 (K), U10.4 (V-), U13.4 (V-), U14.4 (V-), U15.4 (V-), U16.4 (V-), U19.4 (V-), U20.4 (V-), U21.4 (V-); also elsewhere on the board
/IM: R57.1, U19.6; also elsewhere on the board
/IOUT: C28.1, C29.1, C30.1, C31.1, C32.1, R38.1, R39.1, R40.1, R41.1, R42.1, R43.1, R44.1, R45.1, R46.1, R47.1, R48.1, R49.1, R50.1, R51.1; also elsewhere on the board
/VM: R35.1, U14.6; also elsewhere on the board
/smu_ctrl/I1A: U15.8, U18.2; also elsewhere on the board
/smu_ctrl/I1MA: U16.8; also elsewhere on the board
/smu_ctrl/I10MA: U15.16, U16.1; also elsewhere on the board
/smu_ctrl/I10UA: U16.16; also elsewhere on the board
/smu_ctrl/I100MA: U15.9, U17.2; also elsewhere on the board
/smu_ctrl/I100UA: U16.9; also elsewhere on the board
/smu_ctrl/VRANGEL: U12.2; also elsewhere on the board
/smu_ivmeas/GRD_INT: R58.2
/smu_ivmeas/GRD_OUT: R59.1; also elsewhere on the board
/smu_ivmeas/LA10MA: U15.1; also elsewhere on the board
/smu_ivmeas/SEN+: R24.2; also elsewhere on the board
/smu_ivmeas/SEN-: C23.2, R25.2; also elsewhere on the board
GND: C28.2, R33.2, R38.2, R53.2, U15.3, U15.5 (GND), U16.2, U16.5 (GND), U16.6, U16.11, U16.15, U17.3, U18.4; also elsewhere on the board
unnamed: C23.1, D5.3 (K), R25.1, U11.3 (+)
unnamed: C25.1, R26.2, U11.6
unnamed: C25.2, R27.2, U11.2 (-)
unnamed: C29.2, R39.2, U16.14
unnamed: C30.2, R40.2, U16.10
unnamed: C31.2, R41.2, U16.7
unnamed: C32.2, D7.1 (K), D7.2 (A), R51.2, R55.1
unnamed: D4.3 (K), R24.1, U10.3 (+)
unnamed: D6.3 (K), R26.1, R27.1, R29.1, U12.3
unnamed: D7.3 (K), R58.1, R59.2, U21.2 (-), U21.6
unnamed: R28.1, R29.2, R30.2, U13.3 (+)
unnamed: R28.2, R31.1, U10.2 (-), U10.6
unnamed: R30.1, U12.4
unnamed: R31.2, R33.1, U14.3 (+)
unnamed: R32.2, U12.1
unnamed: R34.1, R35.2, U14.2 (-)
unnamed: R34.2, U13.2 (-), U13.6
unnamed: R36.2, U17.1
unnamed: R37.2, U18.1
unnamed: R42.2, U15.14, U16.3
unnamed: R43.2, R44.2, R45.2, R46.2, U15.10, U17.4
unnamed: R47.2, R48.2, R49.2, R50.2, U15.7, U18.3
unnamed: R52.1, U15.2, U15.6, U15.11, U15.15
unnamed: R52.2, R53.1, U19.3 (+)
unnamed: R54.1, R57.2, U19.2 (-)
unnamed: R54.2, R56.1, U20.2 (-), U20.6
unnamed: R55.2, U20.3 (+)
unnamed: R56.2, U21.3 (+)

Notes on the sheet:
Voltage sense input conditioning and range switch
Current sense input conditioning and range switch

Parts:
C33, C37: 22p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C34, C35, C36, C38, C40, C43, C48, C50, C51, C52, C56: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C39, C49, C57: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C41: 1u; C_Rect_L7.0mm_W3.5mm_P5.00mm
C42: 4u7; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder
C44, C45, C46, C47, C53, C54, C55: 1n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D8, D9: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
FB1, FB2, FB3, FB4: Ferrite_Bead_Small; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J6: Conn_02x03_Odd_Even; IDC-Header_2x03_P2.54mm_Vertical
J7: Conn_01x06_Male; PinHeader_1x06_P2.00mm_Vertical
R60: 10k1; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R61, R62: 680R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R63, R64, R66, R68, R70, R71, R73, R74, R75, R76, R77, R78: 10k00; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R65: 2R2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R67, R69, R81, R82: 21k50; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R72: 1M6; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R79: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R80: 20k50; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R83: 2k00; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U22: ISO7341C; SOIC-16W_7.5x10.3mm_P1.27mm
U23: ATmega8535-16JU; PLCC-44
U24: MAX6225; DIP-8_W7.62mm_Socket
U25: OPA2333; SOIC-8_3.9x4.9mm_P1.27mm
U26: LTC2057; SOIC-8_3.9x4.9mm_P1.27mm
U27: AD5686; TSSOP-16_4.4x5mm_P0.65mm
U28: OPA202; SOIC-8_3.9x4.9mm_P1.27mm
U29, U30: OP07; SOIC-8_3.9x4.9mm_P1.27mm
U31: CPC1018N; SO-4_4.4x3.9mm_P2.54mm
U32: ad7177; TSSOP-24_4.4x7.8mm_P0.65mm
Y1: Crystal; Crystal_HC49-4H_Vertical

Connections:
+5V: FB1.2, FB2.1, FB3.2, FB4.2, U25.8 (V+), U32.16 (IOVDD); also elsewhere on the board
+5VD: C34.1, C35.1, C38.1, C39.1, FB1.1, J6.2, J7.6, R60.2, R61.1, U22.1 (VCC1), U23.11 (VCC), U23.23 (VCC), U23.33 (AVCC), U23.35 (AREF), U23.44 (VCC)
+15V: C40.1, U24.2 (IN), U26.7 (V+), U28.7 (V+), U29.7 (V+), U30.7 (V+); also elsewhere on the board
-15V: U26.4 (V-), U28.4 (V-), U29.4 (V-), U30.4 (V-); also elsewhere on the board
/IM: R69.2; also elsewhere on the board
/VM: R67.2; also elsewhere on the board
/VREF+: C41.1, C50.1, R63.2, U24.6 (OUT), U27.1 (VREF), U32.3 (REF+); also elsewhere on the board
/smu_ctrl/CL+: C54.1, R81.2, U29.6; also elsewhere on the board
/smu_ctrl/CL-: C55.1, R82.2, U30.6; also elsewhere on the board
/smu_ctrl/CLAMP: U22.4 (INB), U23.28 (PC3); also elsewhere on the board
/smu_ctrl/COM_RX: U22.6 (OUTD), U23.15 (PD0)
/smu_ctrl/COM_TX: U22.5 (INC), U23.16 (PD1)
/smu_ctrl/CS_ADC: U23.38 (PA5), U32.14 (~CS)
/smu_ctrl/CS_DAC: U23.41 (PA2), U27.13 (~SYNC)
/smu_ctrl/FDACLO: R79.2, U23.36 (PA7)
/smu_ctrl/FDACN: C53.1, R80.2, U28.6, U31.4; also elsewhere on the board
/smu_ctrl/I1A: U23.43 (PA0); also elsewhere on the board
/smu_ctrl/I1MA: U23.4 (PB2); also elsewhere on the board
/smu_ctrl/I10MA: U23.3 (PB1); also elsewhere on the board
/smu_ctrl/I10UA: U23.6 (PB4); also elsewhere on the board
/smu_ctrl/I100MA: U23.42 (PA1); also elsewhere on the board
/smu_ctrl/I100UA: U23.5 (PB3); also elsewhere on the board
/smu_ctrl/IMODE: U23.29 (PC4); also elsewhere on the board
/smu_ctrl/I_CLAMP: U22.13 (OUTB); also elsewhere on the board
/smu_ctrl/I_GND: C36.2, U22.9 (GND2), U22.15 (GND2); also elsewhere on the board
/smu_ctrl/I_RX: U22.12 (OUTC); also elsewhere on the board
/smu_ctrl/I_TX: U22.11 (IND); also elsewhere on the board
/smu_ctrl/I_VCC: C36.1, U22.16 (VCC2); also elsewhere on the board
/smu_ctrl/LED: R62.1, U23.31 (PC6)
/smu_ctrl/MISO: U23.40 (PA3), U27.8 (SDO), U32.11 (DOUT/~RDY)
/smu_ctrl/MOSI: U23.39 (PA4), U27.14 (SDIN), U32.12 (DIN)
/smu_ctrl/OUT_ON: U23.26 (PC1); also elsewhere on the board
/smu_ctrl/PA_CTRL_A: U23.17 (PD2); also elsewhere on the board
/smu_ctrl/PA_CTRL_B: U23.18 (PD3); also elsewhere on the board
/smu_ctrl/P_MISO: J6.1, U23.8 (PB6)
/smu_ctrl/P_MOSI: J6.4, U23.7 (PB5)
/smu_ctrl/P_RST: J6.5, R60.1, U23.10 (~RESET)
/smu_ctrl/P_SCK: J6.3, U23.9 (PB7)
/smu_ctrl/REMOTE: U23.27 (PC2); also elsewhere on the board
/smu_ctrl/SCK: U23.37 (PA6), U27.12 (SCLK), U32.13 (SCLK)
/smu_ctrl/VLDAC: C43.1, FB2.2, U27.5 (VDD), U27.10 (GAIN), U27.11 (VLOGIC), U27.15 (~RESET), U27.16 (RSTSEL)
/smu_ctrl/VMODE: U23.30 (PC5); also elsewhere on the board
/smu_ctrl/VRANGEL: U23.32 (PC7); also elsewhere on the board
/smu_ctrl/VREF-: C42.2, R64.2, R66.2, R68.2, R74.2, R76.2, R78.2, U26.6
/smu_ivmeas/LA10MA: U23.2 (PB0); also elsewhere on the board
GND: C33.2, C34.2, C35.2, C37.2, C38.2, C39.2, C40.2, C41.2, C43.2, C44.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C56.2, C57.2, D8.1 (K), D9.1 (K), J6.6, J7.5, R65.1, U22.2 (GND1), U22.8 (GND1), U23.1 (GND), U23.12 (GND), U23.24 (GND), U23.34 (AGND), U24.4 (GND), U25.3 (+), U25.4 (V-), U25.5 (+), U26.3 (+), U27.4 (GND), U27.9 (~LDAC), U28.3 (+), U29.3 (+), U30.3 (+), U31.2, U32.2 (REF-), U32.6 (AVSS), U32.17 (DGND), U32.22 (AIN1), U32.24 (AIN3); also elsewhere on the board
unnamed: C33.1, U23.14 (XTAL1), Y1.1
unnamed: C37.1, U23.13 (XTAL2), Y1.2
unnamed: C42.1, R65.2
unnamed: C44.1, C45.1, R70.2, U25.1, U32.21 (AIN0)
unnamed: C45.2, R66.1, R67.1, R70.1, U25.2 (-)
unnamed: C46.1, C47.1, R71.2, U25.7, U32.23 (AIN2)
unnamed: C46.2, R68.1, R69.1, R71.1, U25.6 (-)
unnamed: C48.1, C49.1, U32.5 (REGCAPA)
unnamed: C51.1, FB4.1, U32.7 (AVDD1)
unnamed: C52.1, FB3.1, U32.8 (AVDD2)
unnamed: C53.2, R72.1, R73.1, R74.1, R80.1, R83.1, U28.2 (-)
unnamed: C54.2, R75.1, R76.1, R81.1, U29.2 (-)
unnamed: C55.2, R77.1, R78.1, R82.1, U30.2 (-)
unnamed: C56.1, C57.1, U32.18 (REGCAPD)
unnamed: D8.2 (A), R61.2
unnamed: D9.2 (A), R62.2
unnamed: J7.1, U23.22 (PD7)
unnamed: J7.2, U23.21 (PD6)
unnamed: J7.3, U23.20 (PD5)
unnamed: J7.4, U23.19 (PD4)
unnamed: R63.1, R64.1, U26.2 (-)
unnamed: R72.2, U27.2 (VOUTB)
unnamed: R73.2, U27.7 (VOUTD)
unnamed: R75.2, U27.6 (VOUTC)
unnamed: R77.2, U27.3 (VOUTA)
unnamed: R79.1, U31.1
unnamed: R83.2, U31.3

Notes on the sheet:
Optical isolation
Floating MCU
Floating MCU programming header
Reference, ADC, measurement signal conditioning
DAC, main drive and clamp signals conditioning

Board: 2 copper layers, 130.0 x 80.0 mm, 210 parts (13 on the bottom side), 141 nets.

## KiCad design pcb/pcb_kicad/smu_pwr_P1/smu_pwr_1.kicad_pcb

Board: 2 copper layers, 100.0 x 82.0 mm, 42 parts (0 on the bottom side), 20 nets.

Parts:
C1, C2: 1u; C_Rect_L16.5mm_W7.0mm_P15.00mm_MKT
C3, C4: 390u; CP_Radial_D18.0mm_P7.50mm
C5, C6, C7, C8: 470u; CP_Radial_D13.0mm_P5.00mm
C9, C10: 22u; CP_Radial_D6.3mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
D13, D14: 15V; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO7380_Pad
J1: Conn_01x05_Male; Molex_KK-396_A-41791-0005_1x05_P3.96mm_Vertical
J2, J3, J5: Conn_01x03_Male; Molex_KK-396_A-41791-0003_1x03_P3.96mm_Vertical
J4: Conn_01x03_Male; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical
K1: Fujitsu_FTR-F1C; Relay_DPDT_Fujitsu_FTR-F1C
R1, R2: 33R; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R3, R5: 22k; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R4, R6: 10k; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
U1: L7815; TO-220-3_Vertical
U2: L7915; TO-220-3_Vertical

Connections:
/15VO+: C7.1, D11.1, D13.1, J2.1, R4.2
/15VO-: C8.2, D12.1, D14.2, J2.3, R6.1
/+15V: C9.1, J4.1, U1.3
/-15V: C10.2, J4.3, U2.3
/GND: C5.2, C6.1, C9.2, C10.1, J4.2, J5.2, K1.4, U1.2, U2.1
/HV+: C3.1, D1.1, D2.1, J3.3, K1.2
/HV-: C4.2, D3.2, D4.2, J3.1, K1.7
/HVG: C3.2, C4.1, C7.2, C8.1, D9.2, D10.1, D13.2, D14.1, J1.3, J2.2, R3.1, R4.1, R5.1, R6.2
unnamed: C1.1, R1.2
unnamed: C1.2, D1.2, D3.1, J1.1
unnamed: C2.1, R2.2
unnamed: C2.2, D2.2, D4.1, J1.5
unnamed: C5.1, D5.1, D6.1, U1.1
unnamed: C6.2, D7.2, D8.2, K1.5, U2.2
unnamed: D5.2, D7.1, J5.3
unnamed: D6.2, D8.1, J5.1
unnamed: D10.2, D12.2, R2.1
unnamed: D9.1, D11.2, R1.1
unnamed: K1.3, R3.2
unnamed: K1.6, R5.2

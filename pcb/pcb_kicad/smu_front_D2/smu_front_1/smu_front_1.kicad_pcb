# Repository jaromir-sukuba/J-SMU

File README.md:

## What is SMU?
In case you don't know what is SMU, take a look [here](https://en.wikipedia.org/wiki/Source_measure_unit)
Basically, it's glorified power supply, able to both source voltage (and measure current, with current limit) or source current (and measure voltage, with voltage limit), usually in wide range of voltages and currents. It usually works in four quadrants, meaning it's able to both sink and source power. When set to zero output voltage, SMU acts as ammeter and when set to zero current, acts as voltmeter.
It's very useful as general purpose PSU with precise setpoint adjustment, as a tool for measuring high resistances, for testing semiconductors in wide range of voltages or currents. You can do all this things using classic lab tools (PSU, ammeter, voltmeter, switches), SMU offers this all in single package and is designed to be interconnected with computer to automate the tasks.

## What is in this repository?
+ BOM - Bill Of Material. Contains list of components and materials used in this device. Separated by PCBs.
+ firmware - firmware for two microcontrollers running in JSMU
+ mechanical - mechanical parts I designed for this SMU
+ media - minimal amount of pictures
+ pcb
    + pcb_gerber - gerber data in zip files, ready to be manufactured
    + pcb_ibom - interactive BOM files, helping when populating the boards, also helpful to get familiar with the project
    + pcb_kicad - PCB source files, made in Kicad 5.1.10
    + schematics_pdf - all schematics in PDF format, for easy viewing or printing

## What is JSMU?
JSMU is open source implementation of SMU, inspired by Keithley 236 and Dave Erickson's [DIY SMU](http://www.djerickson.com/diy_smu/index.html)

## How to use it?
User and calibration guide is in the process and will be released soon(TM).

Parameters:
+ Voltage ranges 12V and 120V (bipolar)
+ Current ranges 1uA, 10uA, 100uA, 1mA, 10mA, 100mA (bipolar)
+ Minimal set voltage step - 1mV
+ Minimal set current step - 100pA
+ Voltage resolution - 100uV
+ Current resolution - 1pA

JSMU is designed to work as standalone device, but can be connected to computer via USB, and controlled via simple commands in SCPI form, similar to Keithley 2xxx series SMUs.

More pictures can be found in [imgur gallery](https://imgur.com/a/rR8cIFG)

## FAQ
Q: I noticed you used AT90S4434, made in 1999 as controller for your analog board.
- A: Yes, that is correct observation. Two reasons led me to this decision; first of all, I like to do weird design choices from a time to time. Let's call it design dissonances. Secondly, when this design was born (winter 2020/2021-summer 2021) component crisis was (and still is, in the time of writing this) quite strong and I was limited by what components were available. I tried to choose as much components as were available in my junkbox as possible. AT90S4434 can be replaced by AtMega8535 after minor source touchup and recompiling.

Q: dsPIC33FJ128GP306 is also weird choice here
- A: Yes, again, I was fishing in my junkbox. A lot of open-source project go with STM32, but at the time of designing, majority of component suppliers had more-less zero stock of more common STM32's. Once the situation changes, I can think of respinning the D1 board for STM32 and port the code. I already did porting from MC9S08BG60 to dsPIC; perhaps I'll manage another port too.

Q: What is the point of using 14-segment alphanumeric display in 2021, when many test instruments are using graphic LCDs with touchscreens?
- A: Apart from the fact I don't like touch screens on test instruments, I intentionally tried to keep the design in kind-of similar feel than Keithley 236. It's a thing of personal taste.

## KiCad design pcb/pcb_kicad/smu_front_D2/smu_front_1/smu_front_1.kicad_pcb

Parts:
C1: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 1n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 10n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 47u; CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder
C9, C10: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12, C13: 470u; CP_Radial_D6.3mm_P2.50mm
D1: B340; D_SMB_Handsoldering
D2, D3, D4, D5, D6, D7, D8, D9, D10: LED; LED_D3.0mm
D11, D12, D13: LL4148; D_MiniMELF
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_3.2mm_M3_Pad
J2: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J3: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
L1: L; L_Bourns_SRP7028A_7.3x6.6mm
R1, R2, R3, R4, R5: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: 6K8; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R8, R9, R10, R11, R12, R13, R14, R15: 510; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: Rotary_Encoder; RotaryEncoder_Alps_EC12E_Vertical_H20mm_CircularMountingHol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
SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15: SW_Push; MQ_6450
U3: TPS5420D; SOIC-8_3.9x4.9mm_P1.27mm
U4: 74HC14; SOIC-14_3.9x8.7mm_P1.27mm
U5: MCP23S17_SO; SOIC-28W_7.5x17.9mm_P1.27mm

Connections:
+3V3: C9.1, C10.1, J2.16, R1.1, R2.1, U4.14 (VCC), U5.9 (VDD), U5.18 (~RESET~); also elsewhere on the board
/D_A0: J2.9; also elsewhere on the board
/D_A1: J2.11; also elsewhere on the board
/D_A2: J2.13; also elsewhere on the board
/D_CLK: J2.7; also elsewhere on the board
/D_DI: J2.1; also elsewhere on the board
/D_LE: J2.3; also elsewhere on the board
/D_OE: J2.5; also elsewhere on the board
/ENC_A: J2.10, U4.8
/ENC_B: J2.12, U4.4
/E_CS: J2.2, U5.11 (~CS~)
/E_SCK: J2.4, U5.12 (SCK)
/E_SI: J2.6, U5.13 (SI)
/E_SO: J2.8, U5.14 (SO)
/K_C1: D11.2 (A), SW2.2, SW3.2, SW4.2, SW5.2, SW6.2
/K_C2: D12.2 (A), SW7.2, SW8.2, SW9.2, SW10.2, SW11.2
/K_C3: D13.2 (A), SW12.2, SW13.2, SW14.2, SW15.2
/K_R1: SW2.1, SW7.1, SW12.1, U5.4 (GPB3)
/K_R2: SW3.1, SW8.1, SW13.1, U5.5 (GPB4)
/K_R3: SW4.1, SW9.1, SW14.1, U5.6 (GPB5)
/K_R4: SW5.1, SW10.1, SW15.1, U5.7 (GPB6)
/K_R5: SW6.1, SW11.1, U5.8 (GPB7)
/LED_A1: R7.1, R11.1, U5.25 (GPA4)
/LED_A2: R8.1, R12.1, U5.24 (GPA3)
/LED_A3: R9.1, R13.1, U5.23 (GPA2)
/LED_A4: R10.1, R14.1, U5.22 (GPA1)
/LED_A5: R15.1, U5.21 (GPA0)
/LED_C1: D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), U5.26 (GPA5)
/LED_C2: D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), U5.27 (GPA6)
/VLED: C5.1, C12.1, C13.1, L1.2, R5.1; also elsewhere on the board
GND: C1.1, C2.1, C3.1, C5.2, C9.2, C10.2, C12.2, C13.2, D1.2 (A), J2.15, J3.1, J3.2, R6.2, SW1.C, U3.6 (GND), U4.7 (GND), U5.10 (VSS), U5.15 (A0), U5.16 (A1), U5.17 (A2); also elsewhere on the board
unnamed: C1.2, J3.3, J3.4, U3.7 (VIN)
unnamed: C2.2, R4.1, U4.1
unnamed: C3.2, R3.1, U4.5
unnamed: C4.1, D1.1 (K), L1.1, U3.8 (PH)
unnamed: C4.2, U3.1 (BOOT)
unnamed: D2.2 (A), R7.2
unnamed: D3.2 (A), R8.2
unnamed: D4.2 (A), R9.2
unnamed: D5.2 (A), R10.2
unnamed: D6.2 (A), R11.2
unnamed: D7.2 (A), R12.2
unnamed: D8.2 (A), R13.2
unnamed: D9.2 (A), R14.2
unnamed: D10.2 (A), R15.2
unnamed: D11.1 (K), U5.1 (GPB0)
unnamed: D12.1 (K), U5.2 (GPB1)
unnamed: D13.1 (K), U5.3 (GPB2)
unnamed: R1.2, R3.2, SW1.B
unnamed: R2.2, R4.2, SW1.A
unnamed: R5.2, R6.1, U3.4 (VSNS)
unnamed: U4.2, U4.3
unnamed: U4.6, U4.9

Notes on the sheet:
R6 - ULED 5k6 - 3,4V 6k2 - 3.2V 6k8 - 3,0V 7k5 - 2.85V 8k2 - 2.7V 9k1 - 2.55V 10k - 2.44V
Power connector, LED display powersupply
Rotary encoder, contact debouncing
Signal connector
Displays and drivers
Mounting holes
SPI expander, LED matrix, key matrix
JSMU - front panel board D2

Parts:
C6, C7, C8, C11: C; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9: DISP_LTP3786; DISP_LED_18
Q1, Q2, Q3, Q4, Q5, Q6: IRLML6402; SOT-23
R16, R17, R18: 1k5; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U6, U7, U8: STP16CP05; SSOP-24_3.9x8.7mm_P0.635mm
U9: 74LS138; SO-16_3.9x9.9mm_P1.27mm

Connections:
+3V3: C6.1, C7.1, C8.1, C11.1, U6.24 (VDD), U7.24 (VDD), U8.24 (VDD), U9.6 (E3), U9.16 (VCC); also elsewhere on the board
/D_A0: U9.1 (A0); also elsewhere on the board
/D_A1: U9.2 (A1); also elsewhere on the board
/D_A2: U9.3 (A2); also elsewhere on the board
/D_CLK: U6.3 (CLK), U7.3 (CLK), U8.3 (CLK); also elsewhere on the board
/D_DI: U6.2 (SDI); also elsewhere on the board
/D_LE: U6.4 (LE/DM1), U7.4 (LE/DM1), U8.4 (LE/DM1); also elsewhere on the board
/D_OE: U6.21 (~OE/DM2), U7.21 (~OE/DM2), U8.21 (~OE/DM2); also elsewhere on the board
/VLED: Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S); also elsewhere on the board
/smu_front_disp/A0: LED1.12 (A), LED2.12 (A), LED3.12 (A), U6.5 (~OUT0)
/smu_front_disp/A1: LED1.10 (B), LED2.10 (B), LED3.10 (B), U6.6 (~OUT1)
/smu_front_disp/A2: LED1.9 (C), LED2.9 (C), LED3.9 (C), U6.7 (~OUT2)
/smu_front_disp/A3: LED1.7 (D), LED2.7 (D), LED3.7 (D), U6.8 (~OUT3)
/smu_front_disp/A4: LED1.1 (E), LED2.1 (E), LED3.1 (E), U6.9 (~OUT4)
/smu_front_disp/A5: LED1.18 (F), LED2.18 (F), LED3.18 (F), U6.10 (~OUT5)
/smu_front_disp/A6: LED1.15 (G), LED2.15 (G), LED3.15 (G), U6.11 (~OUT6)
/smu_front_disp/A7: LED1.14 (H), LED2.14 (H), LED3.14 (H), U6.12 (~OUT7)
/smu_front_disp/A8: LED1.6 (J), LED2.6 (J), LED3.6 (J), U6.13 (~OUT8)
/smu_front_disp/A9: LED1.5 (K), LED2.5 (K), LED3.5 (K), U6.14 (~OUT9)
/smu_front_disp/A10: LED1.4 (L), LED2.4 (L), LED3.4 (L), U6.15 (~OUT10)
/smu_front_disp/A11: LED1.2 (M), LED2.2 (M), LED3.2 (M), U6.16 (~OUT11)
/smu_front_disp/A12: LED1.13 (N), LED2.13 (N), LED3.13 (N), U6.17 (~OUT12)
/smu_front_disp/A13: LED1.17, LED2.17, LED3.17, U6.18 (~OUT13)
/smu_front_disp/A14: LED1.8 (DP), LED2.8 (DP), LED3.8 (DP), U6.19 (~OUT14)
/smu_front_disp/A15: U6.20 (~OUT15)
/smu_front_disp/B0: LED4.12 (A), LED5.12 (A), LED6.12 (A), U7.5 (~OUT0)
/smu_front_disp/B1: LED4.10 (B), LED5.10 (B), LED6.10 (B), U7.6 (~OUT1)
/smu_front_disp/B2: LED4.9 (C), LED5.9 (C), LED6.9 (C), U7.7 (~OUT2)
/smu_front_disp/B3: LED4.7 (D), LED5.7 (D), LED6.7 (D), U7.8 (~OUT3)
/smu_front_disp/B4: LED4.1 (E), LED5.1 (E), LED6.1 (E), U7.9 (~OUT4)
/smu_front_disp/B5: LED4.18 (F), LED5.18 (F), LED6.18 (F), U7.10 (~OUT5)
/smu_front_disp/B6: LED4.15 (G), LED5.15 (G), LED6.15 (G), U7.11 (~OUT6)
/smu_front_disp/B7: LED4.14 (H), LED5.14 (H), LED6.14 (H), U7.12 (~OUT7)
/smu_front_disp/B8: LED4.6 (J), LED5.6 (J), LED6.6 (J), U7.13 (~OUT8)
/smu_front_disp/B9: LED4.5 (K), LED5.5 (K), LED6.5 (K), U7.14 (~OUT9)
/smu_front_disp/B10: LED4.4 (L), LED5.4 (L), LED6.4 (L), U7.15 (~OUT10)
/smu_front_disp/B11: LED4.2 (M), LED5.2 (M), LED6.2 (M), U7.16 (~OUT11)
/smu_front_disp/B12: LED4.13 (N), LED5.13 (N), LED6.13 (N), U7.17 (~OUT12)
/smu_front_disp/B13: LED4.17, LED5.17, LED6.17, U7.18 (~OUT13)
/smu_front_disp/B14: LED4.8 (DP), LED5.8 (DP), LED6.8 (DP), U7.19 (~OUT14)
/smu_front_disp/C0: LED7.12 (A), LED8.12 (A), LED9.12 (A), U8.5 (~OUT0)
/smu_front_disp/C1: LED7.10 (B), LED8.10 (B), LED9.10 (B), U8.6 (~OUT1)
/smu_front_disp/C2: LED7.9 (C), LED8.9 (C), LED9.9 (C), U8.7 (~OUT2)
/smu_front_disp/C3: LED7.7 (D), LED8.7 (D), LED9.7 (D), U8.8 (~OUT3)
/smu_front_disp/C4: LED7.1 (E), LED8.1 (E), LED9.1 (E), U8.9 (~OUT4)
/smu_front_disp/C5: LED7.18 (F), LED8.18 (F), LED9.18 (F), U8.10 (~OUT5)
/smu_front_disp/C6: LED7.15 (G), LED8.15 (G), LED9.15 (G), U8.11 (~OUT6)
/smu_front_disp/C7: LED7.14 (H), LED8.14 (H), LED9.14 (H), U8.12 (~OUT7)
/smu_front_disp/C8: LED7.6 (J), LED8.6 (J), LED9.6 (J), U8.13 (~OUT8)
/smu_front_disp/C9: LED7.5 (K), LED8.5 (K), LED9.5 (K), U8.14 (~OUT9)
/smu_front_disp/C10: LED7.4 (L), LED8.4 (L), LED9.4 (L), U8.15 (~OUT10)
/smu_front_disp/C11: LED7.2 (M), LED8.2 (M), LED9.2 (M), U8.16 (~OUT11)
/smu_front_disp/C12: LED7.13 (N), LED8.13 (N), LED9.13 (N), U8.17 (~OUT12)
/smu_front_disp/C13: LED7.17, LED8.17, LED9.17, U8.18 (~OUT13)
/smu_front_disp/C14: LED7.8 (DP), LED8.8 (DP), LED9.8 (DP), U8.19 (~OUT14)
/smu_front_disp/CA0: LED1.16 (COM1), LED4.16 (COM1), LED7.16 (COM1), Q1.3 (D)
/smu_front_disp/CA1: LED1.11 (COM2), LED4.11 (COM2), LED7.11 (COM2), Q2.3 (D)
/smu_front_disp/CA2: LED2.16 (COM1), LED5.16 (COM1), LED8.16 (COM1), Q3.3 (D)
/smu_front_disp/CA3: LED2.11 (COM2), LED5.11 (COM2), LED8.11 (COM2), Q4.3 (D)
/smu_front_disp/CA4: LED3.16 (COM1), LED6.16 (COM1), LED9.16 (COM1), Q5.3 (D)
/smu_front_disp/CA5: LED3.11 (COM2), LED6.11 (COM2), LED9.11 (COM2), Q6.3 (D)
GND: C6.2, C7.2, C8.2, C11.2, R16.2, R17.2, R18.2, U6.1 (GND), U7.1 (GND), U8.1 (GND), U9.4 (E1), U9.5 (E2), U9.8 (GND); also elsewhere on the board
unnamed: Q1.1 (G), U9.10 (O5)
unnamed: Q2.1 (G), U9.11 (O4)
unnamed: Q3.1 (G), U9.12 (O3)
unnamed: Q4.1 (G), U9.13 (O2)
unnamed: Q5.1 (G), U9.14 (O1)
unnamed: Q6.1 (G), U9.15 (O0)
unnamed: R16.1, U6.23 (R-EXT)
unnamed: R17.1, U7.23 (R-EXT)
unnamed: R18.1, U8.23 (R-EXT)
unnamed: U6.22 (SDO), U7.2 (SDI)
unnamed: U7.22 (SDO), U8.2 (SDI)

Board: 2 copper layers, 268.0 x 62.0 mm, 90 parts (47 on the bottom side), 115 nets.

## KiCad design pcb/pcb_kicad/smu_back_comm_D3/smu_back_usb.kicad_pcb

Parts:
C1, C4, C6: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 47p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
FB1: Ferrite_Bead_Small; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
H1, H2: MountingHole; MountingHole_3.2mm_M3_ISO7380_Pad
J1: USB_B; USB_B_TE_5787834_Vertical
J2, J3: Conn_01x05_Male; Molex_KK-254_AE-6410-05A_1x05_P2.54mm_Vertical
R1, R2: 27R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R6: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R7: 22k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: FT230XS; SSOP-16_3.9x4.9mm_P0.635mm

Connections:
+3V3: C6.2, J2.2, J3.2, R7.2, U1.3 (VCCIO)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, J1.4 (GND), J1.5 (Shield), J2.1, J3.1, R5.1, U1.5 (GND), U1.13 (GND)
unnamed: C1.1, FB1.2, J1.1 (VBUS)
unnamed: C2.1, J1.2 (D-), R2.2
unnamed: C3.1, J1.3 (D+), R1.2
unnamed: C4.1, U1.10 (3V3OUT), U1.11 (~RESET)
unnamed: J2.3, J3.3, R3.1
unnamed: J2.4, J3.4, R6.2, R7.1
unnamed: J2.5, J3.5, R4.1, R5.2
unnamed: R1.1, U1.8 (USBDP)
unnamed: R2.1, U1.9 (USBDM)
unnamed: R3.2, U1.1 (TXD)
unnamed: R6.1, U1.4 (RXD)
VBUS: C5.1, FB1.1, R4.2, U1.12 (VCC)

Notes on the sheet:
Two connector alternatives
USB-serial converter, powered by USB, IO lines powered by target device
JSMU - communication board, D3

Board: 2 copper layers, 50.0 x 20.0 mm, 20 parts (1 on the bottom side), 14 nets.

## KiCad design pcb/pcb_kicad/smu_amp_A2/smu_amp_1.kicad_pcb

Parts:
C1, C2, C5, C6: 1n; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C3, C4: 2n2; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C7: 2n2; C_Axial_L19.0mm_D7.5mm_P25.00mm_Horizontal
D1, D2: BAV99; SOT-23
D3, D4, D5, D6: BAV199; SOT-23
D7, D8: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO14580_Pad
J1: Conn_01x06_Male; Molex_KK-396_A-41791-0006_1x06_P3.96mm_Vertical
J2: Conn_01x03_Male; Molex_KK-396_A-41791-0003_1x03_P3.96mm_Vertical
Q1, Q2, Q9, Q10: 2N7002; SOT-23
Q3, Q4, Q8: BC807; SOT-23
Q5: BC160; TO-39-3
Q6: BC140; TO-39-3
Q7: BC817; SOT-23
Q11, Q12: IRF620; TO-220-3_Vertical
Q13, Q14: IRF9620; TO-220-3_Vertical
Q15: TIP41; TO-220-3_Vertical
Q16: TIP42; TO-220-3_Vertical
Q17, Q18: IRF7403; SOIC-8_3.9x4.9mm_P1.27mm
R1, R2, R29, R30: 1k; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R3, R4, R5, R6, R7, R8: 47k; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R9, R10: 22k; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R11: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12, R13, R31, R32: 2k2; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R14: 220R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R16: DNP; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R17, R18, R21, R22: 2M2; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R19, R20: 1M; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R23, R24, R25, R26: 47R; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R27, R28: 220R; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R33, R34: 22R; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal

Connections:
+15V: J1.4, Q3.2 (E), Q4.2 (E), Q6.3 (C), R5.1, R6.1, R12.1, R15.1
-15V: J1.1, Q5.3 (C), R9.2, R10.2, R13.2, R16.1
/160V+: C1.1, C7.1, J2.1, Q11.2 (D), R17.2
/160V-: C6.1, C7.2, J2.3, Q14.2 (D), R22.2
/AMP_IN: J1.3, R11.2
/AMP_OUT: C3.2, C4.1, D7.2 (A), D8.1 (K), J1.2, Q1.2 (S), Q2.2 (S), Q7.2 (E), Q8.2 (E), Q9.2 (S), Q10.3 (D), Q17.1 (S), Q17.2 (S), Q17.3 (S), Q18.5 (D), Q18.6 (D), Q18.7 (D), Q18.8 (D), R3.2, R4.2, R14.1, R19.1, R20.1, R31.2, R32.1
/CL_A: Q4.3 (C), Q9.1 (G), Q10.1 (G), R10.1
/CL_B: Q3.3 (C), Q17.4 (G), Q18.4 (G), R9.1
unnamed: C1.2, C2.1, R17.1, R18.2, R23.1
unnamed: C2.2, C3.1, R18.1, R19.2, R24.1
unnamed: C4.2, C5.2, R20.2, R21.1, R25.1
unnamed: C5.1, C6.2, R21.2, R22.1, R26.1
unnamed: D1.1 (K), Q5.1 (E), Q15.1 (B), R12.2
unnamed: D1.3 (K), Q7.3 (C)
unnamed: D2.2 (A), Q6.1 (E), Q16.1 (B), R13.1
unnamed: D2.3 (K), Q8.3 (C)
unnamed: D3.1 (K), Q11.3 (S), Q12.2 (D)
unnamed: D3.3 (K), Q11.1 (G), R23.2
unnamed: D4.1 (K), D7.1 (K), Q12.3 (S), Q15.2 (C)
unnamed: D4.3 (K), Q12.1 (G), R24.2
unnamed: D5.2 (A), D8.2 (A), Q13.3 (S), Q16.2 (C)
unnamed: D5.3 (K), Q13.1 (G), R25.2
unnamed: D6.2 (A), Q13.2 (D), Q14.3 (S)
unnamed: D6.3 (K), Q14.1 (G), R26.2
unnamed: J1.5, R2.1
unnamed: J1.6, R1.1
unnamed: Q1.1 (G), R1.2, R3.1
unnamed: Q1.3 (D), R5.2, R7.2
unnamed: Q2.1 (G), R2.2, R4.1
unnamed: Q2.3 (D), R6.2, R8.2
unnamed: Q3.1 (B), R7.1
unnamed: Q4.1 (B), R8.1
unnamed: Q5.2 (B), Q6.2 (B), R11.1, R14.2
unnamed: Q7.1 (B), R15.2, R27.2, R29.1
unnamed: Q8.1 (B), R16.2, R28.1, R30.1
unnamed: Q9.3 (D), R27.1
unnamed: Q10.2 (S), R28.2
unnamed: Q15.3 (E), R29.2, R33.1
unnamed: Q16.3 (E), R30.2, R34.2
unnamed: Q17.5 (D), Q17.6 (D), Q17.7 (D), Q17.8 (D), R31.1, R33.2
unnamed: Q18.1 (S), Q18.2 (S), Q18.3 (S), R32.2, R34.1

Notes on the sheet:
Current limit settings: 5,6 at 0 -> 0.3mA 5 active -> 3mA 6 active -> 30mA 5 and 6 active -> 200mA
Mounting holes
Power connector, decoupling
I/O connector, current limit switching
Main amplifier block
JSMU - analog board A2

Board: 2 copper layers, 84.0 x 75.0 mm, 73 parts (0 on the bottom side), 41 nets.

# Repository jaromir-sukuba/J-SMU (continued)

## KiCad design pcb/pcb_kicad/smu_subfront_D1/smu_subfront_1.kicad_pcb

Parts:
C1, C11: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: CP; C_Radial_D8.0mm_H11.5mm_P3.50mm
C3, C4, C5, C10, C14, C15: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C8: 47u; CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder
C7, C9: 10n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12, C13: 22p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D6: SM4007; D_MELF
D5, D8: D_Zener; D_MiniMELF
D7: B340; D_SMB_Handsoldering
D9, D10, D11: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad
J1, J5: Conn_01x05_Male; Molex_KK-254_AE-6410-05A_1x05_P2.54mm_Vertical
J2: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_01x02_Male; Molex_KK-396_A-41791-0002_1x02_P3.96mm_Vertical
J4: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J6, J7: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Horizontal
J8: Conn_01x05_Male; PinHeader_1x05_P2.54mm_Horizontal
L1: L; L_Bourns_SRP7028A_7.3x6.6mm
Q1, Q2: BC817; SOT-23
R1, R2, R5, R6: 2k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R7, R10: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 5k6; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11, R12, R13: 510R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; TestPoint_Pad_2.0x2.0mm
U1: L7808; TO-263-3_TabPin2
U2: TPS5420D; SOIC-8_3.9x4.9mm_P1.27mm
U3: PIC24FJxxGA006; LQFP-64_10x10mm_P0.5mm
U4: 25LCxxx; SOIC-8_3.9x4.9mm_P1.27mm
U5: MC9S08GB60A; LQFP-64_10x10mm_P0.5mm
Y1: Crystal; Crystal_HC49-4H_Vertical

Connections:
+3V3: C3.2, C4.2, C5.2, C8.1, C10.2, C14.2, C15.2, D11.2 (A), J1.2, J4.16, J5.2, J8.2, L1.2, R3.1, R5.2, R7.1, R10.1, U3.10 (VDD), U3.19 (AVDD), U3.26 (VDD), U3.38 (VDD), U3.57 (ENVREG), U4.3 (~WP), U4.7 (~HOLD), U4.8 (VCC), U5.24 (Vdd), U5.41 (VREFH), U5.56 (VDDAD)
+24V: C1.2, C2.1, D1.1 (K), D2.1 (K), J2.3, J2.4, U1.1 (IN), U2.7 (VIN)
/ATN1: J1.5, U3.30 (PMA0/AN15/OCFB/CN12/RB15), U5.13 (PTF4)
/ATN2: J5.5, U3.35 (U1RTS/BCLK1/SCK1/INT0/RF6), U5.2 (PTG7)
/D_A0: J4.9, U3.16 (PGD1/EMUD1/PMA6/VREF+/AN0/CN2/RB0), U5.30 (PTD5/TPM2CH2)
/D_A1: J4.11, U3.27 (TCK/PMA11/AN12/RB12), U5.31 (PTD6/TPM2CH3)
/D_A2: J4.13, U3.28 (TDI/PMA10/AN13/RB13), U5.32 (PTD7/TPM2CH4)
/D_CLK: J4.7, U3.24 (TDO/PMA12/AN11/RB11), U5.29 (PTD4/TPM2CH1)
/D_DI: J4.1, U3.21 (U2CTS/C1OUT/AN8/RB8), U5.26 (PTD1/TPM1CH1)
/D_LE: J4.3, U3.22 (PMA7/C2OUT/AN9/RB9), U5.27 (PTD2/TPM1CH2)
/D_OE: J4.5, U3.23 (TMS/PMA13/CVREF/AN10/RB10), U5.28 (PTD3/TPM2CH0)
/EE_CS: R7.2, U3.47 (SOSCI/CN1/RC13), U4.1 (~CS), U5.36 (PTB3/AD1P3)
/EE_MISO: U3.46 (OC1/RD0), U4.2 (MISO), U5.35 (PTB2/AD1P2)
/EE_MOSI: U3.45 (IC4/PMCS1/INT4/RD11), U4.5 (MOSI), U5.34 (PTB1/AD1P1)
/EE_SCK: U3.44 (IC3/PMCS2/INT3/RD10), U4.6 (SCK), U5.33 (PTB0/AD1P0)
/ENC_A: J4.10, U3.15 (PGC1/EMUC1/VREF-/AN1/CN3/RB1), U5.46 (PTA0/KBI1P0)
/ENC_B: J4.12, U3.14 (C2IN-/AN2/SS1/CN4/RB2), U5.47 (PTA1/KBI1P1)
/E_CS: J4.2, U3.3 (PMD7/RE7), U5.17 (PTE2/SS1)
/E_SCK: J4.4, U3.11 (C1IN+/AN5/CN7/RB5), U5.20 (PTE5/SPSCK1)
/E_SI: J4.6, U3.12 (C1IN-/AN4/CN6/RB4), U5.19 (PTE4/MOSI1)
/E_SO: J4.8, U3.13 (C2IN+/AN3/CN5/RB3), U5.18 (PTE3/MISO1)
/FAN_ON: R2.2, U3.42 (IC1/RTCC/INT1/RD8), U5.51 (PTA5/KBI1P5)
/FAN_SPEED: R1.2, U3.43 (IC2/U1CTS/INT2/RD9), U5.52 (PTA6/KBI1P6)
/LED1: D10.2 (A), U3.2 (PMD6/RE6), U5.10 (PTC7)
/LED2: D9.2 (A), U3.1 (PMD5/RE5), U5.9 (PTC6)
/PG1: J8.5, U3.18 (PGD2/EMUD2/AN7/RB7)
/PG2: J8.3, U3.17 (PGC2/EMUC2/AN6/OCFA/RB6), U5.58 (PTG0/BKGD/MS)
/RST: J8.4, R10.2, U3.7 (MCLR), U5.1 (RESET)
/RX1: J1.3, U3.34 (U1RX/SDI1/RF2), U5.15 (PTE1/RxD1)
/RX2: J5.3, U3.31 (PMA9/U2RX/SDA2/CN17/RF4), U5.4 (PTC1/RxD2)
/SCL: U5.6 (PTC3/SCL1)
/SDA: U5.5 (PTC2/SDA1)
/TH_ADC: C9.2, R6.2, U3.29 (PMA1/U2RTS/BCLK2/AN14/RB14), U5.40 (PTB7/AD1P7)
/TX1: J1.4, U3.33 (U1TX/SDO1/RF3), U5.14 (PTE0/TxD1)
/TX2: J5.4, U3.32 (PMA8/U2TX/SCL2/CN18/RF5), U5.3 (PTC0/TxD2)
/X1: C12.2, R8.1, R9.2, U3.39 (OSC1/CLKI/RC12), Y1.1
/X2: C13.2, R8.2, U3.40 (OSC2/CLKO/RC15), U5.59 (PTG1/XTAL), Y1.2
GND: C1.1, C2.2, C3.1, C4.1, C5.1, C6.2, C8.2, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, D3.2 (A), D4.2 (A), D5.2 (A), D7.2 (A), D8.2 (A), J1.1, J2.1, J2.2, J4.15, J5.1, J7.1, J8.1, Q1.2 (E), Q2.2 (E), R4.2, R11.1, R12.1, R13.1, U2.6 (GND), U3.9 (VSS), U3.20 (AVSS), U3.25 (VSS), U3.41 (Vss), U4.4 (GND), U5.23 (Vss), U5.42 (VREFL), U5.57 (VSSAD)
unnamed: C6.1, D6.1 (K), J6.1, U1.3 (OUT)
unnamed: C7.1, D7.1 (K), L1.1, U2.8 (PH)
unnamed: C7.2, U2.1 (BOOT)
unnamed: C11.2, U3.56 (VCAP/VDDCORE)
unnamed: D1.2 (A), D3.1 (K), J3.2
unnamed: D2.2 (A), D4.1 (K), J3.1
unnamed: D5.1 (K), Q1.3 (C), U1.2 (GND)
unnamed: D6.2 (A), J6.2, Q2.3 (C)
unnamed: D8.1 (K), J7.2, R5.1, R6.1
unnamed: D9.1 (K), R11.2
unnamed: D10.1 (K), R12.2
unnamed: D11.1 (K), R13.2
unnamed: Q1.1 (B), R1.1
unnamed: Q2.1 (B), R2.1
unnamed: R3.2, R4.1, U2.4 (VSNS)
unnamed: R9.1, U5.60 (PTG2/EXTAL)
unnamed: TP1.1, U3.60 (PMD0/RE0)
unnamed: TP2.1, U3.61 (PMD1/RE1)
unnamed: TP3.1, U3.62 (PMD2/RE2)
unnamed: TP4.1, U5.48 (PTA2/KBI1P2)
unnamed: TP5.1, U5.49 (PTA3/KBI1P3)
unnamed: TP6.1, U5.50 (PTA4/KBI1P4)

Notes on the sheet:
Main MCU block. Populate only one MCU footprint
IO connector
RTD connector, signal conditioning
Serial connectors
Fan speed control
24V supply, 3V3 supply
Mounting holes
JSMU - digital board D1

Board: 2 copper layers, 137.0 x 62.0 mm, 66 parts (5 on the bottom side), 58 nets.

## KiCad design pcb/pcb_kicad/smu_switch_P2/smu_switch.kicad_pcb

Parts:
F1: Fuse; Fuseholder_Cylinder-5x20mm_Schurter_0031_8201_Horizontal_Op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
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO7380_Pad
J1, J2: Conn_01x05_Male; Molex_KK-396_A-41791-0005_1x05_P3.96mm_Vertical
SW1: SW_DPST; NE18-2P

Connections:
unnamed: F1.1, J2.1
unnamed: F1.2, SW1.2
unnamed: J1.1, SW1.1
unnamed: J1.3, SW1.3
unnamed: J1.5, J2.5
unnamed: J2.3, SW1.4

Notes on the sheet:
JSMU - switch board P2

Board: 2 copper layers, 38.0 x 113.0 mm, 8 parts (0 on the bottom side), 6 nets.

## Commit log

2021-08-13 first release
2021-08-13 updated readme, added majority of files
2021-08-13 binary files cleanup
2021-08-13 updated BOM
2021-08-14 schematics touch-up
2021-08-14 corrected error in PSU schematics
2022-02-24 SPCI control added
